Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-15T10:56:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 15 10:56:02 2023 * Host: ZILBY3SGS3 * Database: C:\Users\SMalaya\AppData\Local\Temp\e18e194a-78c4-4475-a058-e2494ee0835c\fd7833a2-765d-4750-873e-d4d3ac95134f\ifc * Database version: 5507 * Database creation date: Fri Dec 15 10:56:01 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 15 10:56:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 15 10:56:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: NSFB360-J:NSFB360-J, NSFB360-J:NSFB360-J:763135
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: NSFB360-J
Pset_DistributionFlowElementCommon - Reference: NSFB360-J; sets with these values: 2
